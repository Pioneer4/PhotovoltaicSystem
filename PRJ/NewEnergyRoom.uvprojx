# Keil uVision project NewEnergyRoom.uvprojx, settings and files
target NewEnergyRoom (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PhotovoltaicSystem
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\DEVICE;..\DEVICE\LCD;..\DEVICE\TOUCH;..\LIB\inc;..\SYSTEM;..\CORE;..\DEVICE\SDIO;..\MALLOC;..\FATFS\exfuns;..\FATFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: game.c main.c stm32f4xx_it.c MyTypeDef.h
  group DEVICE
    ../DEVICE/LCD/: lcd.c
    ../DEVICE/TOUCH/: touch.c
    ../DEVICE/: hmi_uart.c iwdg.c key.c led.c spi.c timer.c w25qxx.c GY39uart.c adc.c pwmLed.c pwmMos.c relay.c
    ../DEVICE/SDIO/: sdio_sdcard.c
  group SYS
    ../SYSTEM/: delay.c sys.c uart.c
  group LIB
    ../LIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_adc.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group NOTE
    ../NOTE/: brief.txt
